File: uUSB breakout/uUSB breakout v1.brd (EAGLE design)
At the start: 13.3 x 16.5 mm, 8 parts

Commit message: updated .brd
Routing:
- net GND: track 0.00 -> 1.90 mm, vias 2 -> 5
